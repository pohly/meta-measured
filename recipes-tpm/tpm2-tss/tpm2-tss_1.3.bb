include ${BPN}.inc

SRCREV = "8107deb5da497d66044a95a392e177122b2bf664"
SRC_URI = "git://github.com/01org/${BPN}.git;protocol=git;name=${BPN};destsuffix=${BPN};branch=1.x"
