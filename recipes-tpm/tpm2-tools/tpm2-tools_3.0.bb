include tpm2-tools.inc

SRCREV = "4ab96a4e76e498d826a8f67906bf30556effcf2b"
